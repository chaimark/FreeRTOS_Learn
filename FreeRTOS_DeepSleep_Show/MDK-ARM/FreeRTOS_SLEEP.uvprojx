# Keil uVision project FreeRTOS_SLEEP.uvprojx, settings and files
target FreeRTOS_DeepSleep (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33LC02X FMSH
  pack: FMSH.FM33LC0XX_DFP.3.0.4
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ADC_Poll +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: FM33LC0XX,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\FM33LC0xx_FL_Driver\Inc;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\MF-config\Inc;..\Inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM0;..\Tickless;..\Src
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group FreeRTOS_Tickless
    ../Tickless/: Tickless_Hook.c
  group FreeRTOS_Portable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
  group FreeRTOS_Code
    ../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
  group Drivers/FM33LC0xx_FL_Driver
    ../Drivers/FM33LC0xx_FL_Driver/Src/: fm33lc0xx_fl.c fm33lc0xx_fl_adc.c fm33lc0xx_fl_aes.c fm33lc0xx_fl_atim.c fm33lc0xx_fl_bstim32.c fm33lc0xx_fl_comp.c fm33lc0xx_fl_crc.c fm33lc0xx_fl_dma.c fm33lc0xx_fl_exti.c fm33lc0xx_fl_flash.c fm33lc0xx_fl_gpio.c fm33lc0xx_fl_gptim.c fm33lc0xx_fl_divas.c fm33lc0xx_fl_i2c.c fm33lc0xx_fl_iwdt.c fm33lc0xx_fl_lptim32.c fm33lc0xx_fl_lpuart.c fm33lc0xx_fl_opa.c fm33lc0xx_fl_pmu.c fm33lc0xx_fl_rcc.c fm33lc0xx_fl_rng.c fm33lc0xx_fl_rtc.c fm33lc0xx_fl_spi.c fm33lc0xx_fl_svd.c fm33lc0xx_fl_u7816.c fm33lc0xx_fl_uart.c fm33lc0xx_fl_wwdt.c fm33lc0xx_fl_lcd.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/arm/: startup_fm33lc0xx.s
  group Application/MF-Config
    ../MF-config/Src/: mf_config.c
  group Application/Interflow
    ../Interflow/: AT24CXXDataLoader.c AT24CXXDataLoader.h Check_XTHF_Or_XTLF.c Check_XTHF_Or_XTLF.h Define.c Define.h NumberBaseLib.c NumberBaseLib.h PublicLib_No_One.c PublicLib_No_One.h RTC.c RTC.h RTC_SetTime.c RTC_SetTime.h SetTime.c SetTime.h StrLib.c StrLib.h
  group Application/User
    ../Src/: ADC.c ADC.h AT24C02.c AT24C02.h BSTim.c BSTim.h gpio.c gpio.h LPTim32.c LPTim32.h main.c main.h taskgpio.c taskgpio.h
